# Keil uVision project template_arterytek_at32f415.uvprojx, settings and files
target project (6160000::V6.16::ARMCLANG)
  device: -AT32F415R8T7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project_arterytek_at32f415
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: AT32F415RBT7
  c include: .\..\;.\reference;.\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=os_cb_sections
  group setup
    ./setup/: Lowlevel.cpp Main.cpp Entry.cpp
  group reference
    ./reference/: chip_interrupt.cpp chip_startup.s
  group library
    ../mframe/: mframe_cm3.lib
    ../rtos_rtx5/: rtos_rtx5_m3.lib
    ../chip_arterytek_at32f415/: chip_arterytek_at32f415.lib
    ../core_arterytek_at32f415/: core_arterytek_at32f415.lib
